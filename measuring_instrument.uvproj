# Keil uVision project measuring_instrument.uvproj, settings and files
target Target 1 (MCS-51)
  device: ADuC841 Analog Devices
  cpu: IRAM(0-0xFF) IROM(0-0xF7FF) XRAM (0-0x7FF) CLOCK(12000000) DPX MODAB2
  output: measuring_instrument
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: START_AD.A51 main.c ADuC841.h typedef.h display.c
